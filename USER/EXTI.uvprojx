# Keil uVision project EXTI.uvprojx, settings and files
target EXTI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EXIT +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\BEEP;..\HARDWARE\UltrasonicWave;..\HARDWARE\timer;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\TOUCH;..\HARDWARE\SPI;..\HARDWARE\24CXX;..\HARDWARE\W25QXX;..\HARDWARE\LCD;..\HARDWARE\ATK-ESP8266;..\HARDWARE\DHT11;..\HARDWARE\MALLOC;..\HARDWARE\USART3;..\HARDWARE\USMART;..\HARDWARE\ITEMP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/UltrasonicWave/: wave.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/touch/: touch.c
    ../HARDWARE/24cxx/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/USMART/: usmart.c usmart_config.c usmart_str.c
    ../HARDWARE/ITEMP/: tsensor.c
    ../STM32F10x_FWLib/src/: stm32f10x_adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_spi.c
  group README
    ../: README.TXT
  group ATK
    ../HARDWARE/ATK-ESP8266/: apsta.c common.c wifiap.c wifista.c
